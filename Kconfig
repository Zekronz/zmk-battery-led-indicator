## Kconfig
```kconfig
config ZMK_BATTERY_LED_INDICATOR
    bool "Battery LED indicator"
	select ZMK_BATTERY_REPORTING
    default y
```
